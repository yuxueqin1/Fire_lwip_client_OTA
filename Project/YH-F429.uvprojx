# Keil uVision project YH-F429.uvprojx, settings and files
target LwIP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F429 +hex
  AfterMake: fromelf --bin --output ..\Output\YH-F429.bin   ..\Output\YH-F429.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\usart;..\User\led;..\User\sdram;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\User\arch;..\User\cm_backtrace;..\mbmaster\ascii;..\mbmaster\common;..\mbmaster\functions;..\mbmaster\rtu;..\mbslave\ascii;..\mbslave\functions;..\mbslave\rtu;..\mbslave\tcp;..\mbport;..\User\eeprom;..\User\eth;..\User\ota;..\User\dip_switch
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../User/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c client.c task_rs485_7.c
    ../User/usart/: bsp_debug_usart.c bsp_rs485.c
    ../User/led/: bsp_led.c
    ../User/sdram/: bsp_sdram.c
    ../User/eth/: bsp_eth.c
    ../User/eeprom/: bsp_eeprom.c
    ../User/ota/: ota_client.c ota_crc32.c ota_flash.c ota_manager.c ota_net.c
    ../User/dip_switch/: bsp_dip_switch.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group LwIP/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../LwIP/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../User/arch/: ethernetif.c sys_arch.c
  group cm_backtrace
    ../User/cm_backtrace/: cm_backtrace.c
    ../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group mb_master
    ../mbmaster/ascii/: mbmascii.c mbmascii.h
    ../mbmaster/common/: mbframe.h mbportlayer.h mbtypes.h mbutils.c mbutils.h
    ../mbmaster/functions/: mbm.c mbm.h mbmfunccoils.c mbmfuncdisc.c mbmfuncholding.c mbmfuncinput.c mbmfuncraw.c mbmi.h mbmiconfig.h mbmiframe.h
    ../mbmaster/rtu/: mbmcrc.c mbmcrc.h mbmrtu.c mbmrtu.h
    ../mbmaster/tcp/: mbmtcp.c mbmtcp.h
  group mb_slave
    ../mbslave/ascii/: mbsascii.c mbsascii.h
    ../mbslave/functions/: mbs.c mbs.h mbsfunccoils.c mbsfuncdisc.c mbsfuncholding.c mbsfuncinput.c mbsfunctions.h mbsi.h mbsiconfig.h mbsiframe.h
    ../mbslave/rtu/: mbscrc.c mbscrc.h mbsrtu.c mbsrtu.h
    ../mbslave/tcp/: mbstcp.c mbstcp.h
  group mb_port
    ../mbport/: mbmconfig.h mbport.h mbportevent.c mbportother.c mbportserial.c mbporttimer.c mbsconfig.h
